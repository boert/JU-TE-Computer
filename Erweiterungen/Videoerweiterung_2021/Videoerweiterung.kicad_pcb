# Repository boert/JU-TE-Computer (continued)

## KiCad design Erweiterungen/Tastatur/Tastatur.kicad_pcb (continued)

Board: 2 copper layers, 185.0 x 105.0 mm, 55 parts (0 on the bottom side), 22 nets.

## KiCad design Erweiterungen/Magnetbandanschluss/Magnetbandanschluss.kicad_pcb

Parts:
C13, C16: 10nF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C14: 51pF; C_Axial_L3.8mm_D2.6mm_P12.50mm_Horizontal
C15: 22nF; C_Axial_L3.8mm_D2.6mm_P12.50mm_Horizontal
C17: 4,7µF/16V; CP_Radial_D5.0mm_P2.50mm
C18: 1µF/40V; CP_Radial_D6.3mm_P2.50mm
LS1: 4-100 Ohm
R13: 100; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R14, R15, R19: 22k; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R16: 47k; Potentiometer_Piher_PT-10-H01_Horizontal
R17, R18: 100k; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
T1: SC307; TO-92L_Inline_Wide
TP1: E; Pin_D1.0mm_L10.0mm
TP2: A; Pin_D1.0mm_L10.0mm
TP3: L; Pin_D1.0mm_L10.0mm
TP4: D; Pin_D1.0mm_L10.0mm
U16: DL000D; DIP-14_W7.62mm_Socket
U17: B555D; DIP-8_W7.62mm_Socket
U18: B761D; DIP-6_W7.62mm_Socket
X1: +5V; Pin_D1.0mm_L10.0mm
X2: P3.7; Pin_D1.0mm_L10.0mm
X3: P3.6; Pin_D1.0mm_L10.0mm
X4: 00; Pin_D1.0mm_L10.0mm
X12: P3.0; Pin_D1.0mm_L10.0mm
X13: DIN-3

Connections:
+5P: C17.1, R13.2, R15.2, R16.1, R17.2, U16.14 (Vcc), U17.4 (RES), U17.8 (Vcc), U18.1 (+), X1.1
/A: C14.2, R19.2, TP2.1, X13.1
/E: C16.1, TP1.1, X13.3
/P30: U17.3 (OUT), X12.1
/P36: U16.2 (B1), U16.9 (A3), X3.1
/P37: U16.1 (A1), U16.12 (A4), U16.13 (B4), X2.1
GND: C13.2, C15.2, C17.2, LS1.2, R16.3, R18.1, R19.1, T1.1 (C), U16.4 (A2), U16.5 (B2), U16.7 (GND), U17.1 (GND), U18.4 (-), X4.1, X13.2
unnamed: C13.1, C14.1, R14.2
unnamed: C15.1, R15.1, U17.2 (TRIG), U17.6 (COMP), U18.5
unnamed: C16.2, R17.1, R18.2, U18.3 (-)
unnamed: C18.1, R13.1, T1.3 (E), TP4.1
unnamed: C18.2, LS1.1, TP3.1
unnamed: R14.1, U16.3 (Y1)
unnamed: R16.2, U18.2 (+)
unnamed: T1.2 (B), U16.8 (Y3)
unnamed: U16.10 (B3), U16.11 (Y4)

Notes on the sheet:
Quelle: jutecomp1.pdf S. 22
Quelle: JU+TE 12/1987, Seite 930-932
Signal
0=LSP 1=MBG

Board: 2 copper layers, 40.0 x 40.0 mm, 26 parts (0 on the bottom side), 16 nets.

## KiCad design Erweiterungen/Speichermodul_Typ_B/Speichermodul_Typ_B.kicad_pcb

Parts:
C3: 22nF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C4: 22µF/10V; CP_Radial_D6.3mm_P2.50mm
C5: 47µF/10V; CP_Radial_D8.0mm_P3.50mm
R1, R2, R3, R4: 15k; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
U2: U2716 (U2732); DIP-24_W15.24mm_Socket
U3: U6516D; DIP-24_W15.24mm_Socket
U15: DS8205D; DIP-16_W7.62mm_Socket
X10: Sp.-Modul; PinHeader_1x29_P2.54mm_Horizontal
X11: selects; PinHeader_1x03_P2.54mm_Vertical

Connections:
+5P: C3.1, C4.1, U2.24 (Udd), U15.16 (Vcc), X10.28
/A0: U2.8 (A0), U3.8 (A0), X10.17
/A1: U2.7 (A1), U3.7 (A1), X10.18
/A2: U2.6 (A2), U3.6 (A2), X10.19
/A3: U2.5 (A3), U3.5 (A3), X10.20
/A4: U2.4 (A4), U3.4 (A4), X10.21
/A5: U2.3 (A5), U3.3 (A5), X10.22
/A6: U2.2 (A6), U3.2 (A6), X10.23
/A7: U2.1 (A7), U3.1 (A7), X10.24
/A8: U2.23 (A8), U3.23 (A8), X10.4
/A9: U2.22 (A9), U3.22 (A9), X10.5
/A10: U2.19 (A10), U3.19 (A10), X10.6
/A11: U2.21 (A11), U15.1 (C), X10.7
/A12: U15.2 (B), X10.8
/D0: U2.9 (D0), U3.9 (IO1), X10.16
/D1: U2.10 (D1), U3.10 (IO2), X10.15
/D2: U2.11 (D2), U3.11 (IO3), X10.14
/D3: U2.13 (D3), U3.13 (IO4), X10.13
/D4: U2.14 (D4), U3.14 (IO5), X10.12
/D5: U2.15 (D5), U3.15 (IO6), X10.11
/D6: U2.16 (D6), U3.16 (IO7), X10.10
/D7: U2.17 (D7), U3.17 (IO8), X10.9
/~CSA: U15.4 (~E1), U15.5 (~E2), X10.1
GND: C3.2, C4.2, C5.2, U2.12 (Uss), U3.12 (Uss), U15.3 (A), U15.8 (GND), X10.25
unnamed: R1.2, U15.15 (Y0), X11.1
unnamed: R2.2, U15.14 (Y1), X11.2
unnamed: R3.2, U15.13 (Y2), X11.3
unnamed: R4.2, U3.18 (~CS), U3.20 (~OE), U15.12 (Y3)
R~W: U3.21 (~WE), X10.3
U1: U15.6 (E3), X10.26
U2: C5.1, R1.1, R2.1, R3.1, R4.1, U3.24 (Udd), X10.27
~CSB: U2.18 (~CE~/PGM), U2.20 (~OE~/Upp), X10.2

Notes on the sheet:
für 1. System-RAM nur Drahtbrücke, sonst Adressdekoder bestücken
Quelle: JU+TE 06/1988, Seite 442-445
Quelle: jutecomp2.pdf S. 11
Bestückung nach Bedarf
Auswahl 2 kByte
Batteriestützung möglich
2 kByte RAM-Speicher (max. 8 kByte)
2 kByte (4 kByte) EPROM-Speicher
bis auf 4 Schaltkreise erweiterbar Huckepack, ~CS~/~OE~ jeweils mit einem ~select~ verbinden
Brücke
Grundmodul 2k EPROM, 2k-8k RAM

Board: 2 copper layers, 80.0 x 52.0 mm, 12 parts (0 on the bottom side), 32 nets.

## KiCad design Erweiterungen/Speichermodul_VRAM/Speichermodul_Typ_VRAM.kicad_pcb

Parts:
C3: 10nF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C5: 10µF/10V; CP_Radial_D6.3mm_P2.50mm
U3: U6264D; DIP-28_W15.24mm_Socket
X10: Sp.-Modul; PinHeader_1x29_P2.54mm_Horizontal

Connections:
+5P: X10.28
/A0: U3.10 (A0), X10.17
/A1: U3.9 (A1), X10.18
/A2: U3.8 (A2), X10.19
/A3: U3.7 (A3), X10.20
/A4: U3.6 (A4), X10.21
/A5: U3.5 (A5), X10.22
/A6: U3.4 (A6), X10.23
/A7: U3.3 (A7), X10.24
/A8: U3.25 (A8), X10.4
/A9: U3.24 (A9), X10.5
/A10: U3.21 (A10), X10.6
/A11: U3.23 (A11), X10.7
/A12: U3.2 (A12), X10.8
/D0: U3.11 (IO1), X10.16
/D1: U3.12 (IO2), X10.15
/D2: U3.13 (IO3), X10.14
/D3: U3.15 (IO4), X10.13
/D4: U3.16 (IO5), X10.12
/D5: U3.17 (IO6), X10.11
/D6: U3.18 (IO7), X10.10
/D7: U3.19 (IO8), X10.9
/~CSA: U3.20 (~CS1), U3.22 (~OE), X10.1
GND: C3.2, C5.2, U3.14 (Uss), X10.25
R~W: U3.27 (~WE), X10.3
U1: U3.26 (CS2), X10.26
U2: C3.1, C5.1, U3.28 (Udd), X10.27

Notes on the sheet:
wie Speichermodul Typ C ohne EPROM
8 kByte RAM-Speicher
Erweiterungsmodul 8k RAM (z.B. für Videoerweiterung)

Board: 2 copper layers, 80.0 x 24.0 mm, 4 parts (0 on the bottom side), 26 nets.

## KiCad design Tiny_2k/Tiny2k.kicad_pcb

File Tiny_2k/README.md:

# KiCad-Projekt für JU+TE Computer

## Versionsgeschichte

### Version 1
nach Originallayout

### Version 2
- Bestückungsdruck ergänzt
- Footprint für C5 verlängert
- U14 stehend, statt liegend
- Footprint für D3 überarbeitet
- Footprints für Widerstände überarbeitet

Notes on the sheet:
%0000 - %07FF
2kB interner ROM des UB8830
%0800 - %0FFF
2kB EPROM
%E000 - %E3FF
1kB RAM
(%FC00 - %FFFF)
1kB RAM (mehrfach eingeblendet)
Minimalvariante Speichermodul A (2k EPROM, 1k RAM) auf Steckplatz 1
1kB RAM (/CS0)
%FC00 - %FFFF
1kB RAM (/CS7)
Speichermodul A aufgerüstet mit 1x DS8205, 2k RAM (huckepack) oder Speichermodul B (2k EPROM, 2k RAM)
%E000 - %FFFF
8kB RAM (/CS0.../CS7)
Speichermodul A aufgerüstet mit 1x DS8205, 8k RAM (huckepack) oder Speichermodul B aufgerüstet mit 1x DS8205, 8k RAM
%0800 - %1FFF
6kB EPROM (Steckplatz 1)
8kB RAM (Steckplatz 1)
Speichermodul C (8k RAM, 8k EPROM)
6kB EPROM (auf Steckplatz 1)
%C000 - %DFFF
8kB RAM (Steckplatz 2)
4x Speichermodul C mit 32k RAM und 30k EPROM
%8000 - %9FFF
8kB RAM (Steckplatz 4)
%A000 - %BFFF
8kB RAM (Steckplatz 3)
%2000 - %3FFF
8kB EPROM (auf Steckplatz 2)
%4000 - %5FFF
8kB EPROM (auf Steckplatz 3)
%6000 - %7FFF
8kB EPROM (auf Steckplatz 4), Zusatzdekoder wg. Tastatur nötig
Speicherausbau (Varianten)
Portbelegung
Maximale Last pro Portpin: 0 = low = 2 mA 1 = high = 250 µA
P20 frei P21 frei P22 frei P23 frei P24 frei P25 frei P26 frei P27 frei
P30 Magnetband, Eingabe P31 frei (nur Eingang) P32 frei (nur Eingang) P33 frei (nur Eingang) P34 frei (nur Ausgang), ggf. Bankumschaltung P35 frei (nur Ausgang) P36 akustische Ausgabe P37 Video-Syncronsignal und Umschaltsignal für akustische Ausgabe

Parts:
C1: 2,2µF/40V; CP_Radial_D6.3mm_P2.50mm
C6: 33pF; C_Disc_D4.3mm_W1.9mm_P5.00mm
D1, D2: SAY30; D_T-1_P2.54mm_Vertical_AnodeUp
Q1: 8000 kHz; Crystal_HC18-U_Vertical
R3: 470; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R4: 2,7k; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R5, R6: 3,3k; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R7: 6,8k; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R8, R9, R10, R11: 15k; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
TP1: ~Reset; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: UB8830; DIP-40_W15.24mm_Socket
U5: DS8205D; DIP-16_W7.62mm_Socket
U6: DS8212D; DIP-24_W15.24mm_Socket
U8: V40098D; DIP-16_W7.62mm_Socket
U9: DL000D; DIP-14_W7.62mm_Socket
U10: DL030D; DIP-14_W7.62mm_Socket
U11: DL074D; DIP-14_W7.62mm_Socket
U12, U13: D195D; DIP-14_W7.62mm_Socket
X2: P20-27,P30-37; Altech_AK300_1x16_P5.00mm_45-Degree
X3: Modul 1; PinSocket_1x29_P2.54mm_Vertical
X4: Modul 2; PinSocket_1x29_P2.54mm_Vertical
X5: Modul 3; PinSocket_1x29_P2.54mm_Vertical
X6: Modul 4; PinSocket_1x29_P2.54mm_Vertical
X8: Video; PinSocket_1x02_P2.54mm_Vertical
X9: Versorgung; TerminalBlock_bornier-4_P5.08mm
X71: Spalten; TerminalBlock_bornier-4_P5.08mm
X72: Zeilen; TerminalBlock_bornier-6_P5.08mm

Connections:
+5P: R4.2, R5.2, R8.2, R9.2, R10.2, R11.2, U1.1 (Vcc), U5.6 (E3), U5.16 (Vcc), U6.2 (MD), U6.13 (S2), U6.14 (~CLR), U6.24 (Vcc), U8.16 (Vcc), U9.14 (Vcc), U10.14 (Vcc), U11.1 (R1), U11.10 (S2), U11.14 (Vcc), U12.1 (ES), U12.14 (Vcc), U13.14 (Vcc), X3.28, X4.28, X5.28, X6.28, X9.1, X72.6; also elsewhere on the board
/Hauptplatine/A0: U6.4 (Y1), X3.17, X4.17, X5.17, X6.17, X72.1
/Hauptplatine/A1: U6.6 (Y2), X3.18, X4.18, X5.18, X6.18, X72.2
/Hauptplatine/A2: U6.8 (Y3), X3.19, X4.19, X5.19, X6.19, X72.3
/Hauptplatine/A3: U6.10 (A4), X3.20, X4.20, X5.20, X6.20, X72.4
/Hauptplatine/A4: U6.21 (Y8), X3.21, X4.21, X5.21, X6.21
/Hauptplatine/A5: U6.19 (Y7), X3.22, X4.22, X5.22, X6.22
/Hauptplatine/A6: U6.17 (Y6), X3.23, X4.23, X5.23, X6.23
/Hauptplatine/A7: U6.15 (Y5), X3.24, X4.24, X5.24, X6.24
/Hauptplatine/A8: U1.13 (P00), X3.4, X4.4, X5.4, X6.4
/Hauptplatine/A9: U1.14 (P01), U10.6 (F), X3.5, X4.5, X5.5, X6.5
/Hauptplatine/A10: U1.15 (P02), U10.5 (E), X3.6, X4.6, X5.6, X6.6
/Hauptplatine/A11: U1.16 (P03), U10.4 (D), X3.7, X4.7, X5.7, X6.7
/Hauptplatine/A12: U1.17 (P04), U10.3 (C), X3.8, X4.8, X5.8, X6.8
/Hauptplatine/A13: U1.18 (P05), U5.1 (C), U10.2 (B)
/Hauptplatine/A14: U1.19 (P06), U5.2 (B), U10.1 (A)
/Hauptplatine/A15: U1.20 (P07), U5.3 (A), U10.12 (H)
/Hauptplatine/D0: U1.21 (P10), U6.3 (A1), U12.2 (A), X3.16, X4.16, X5.16, X6.16
/Hauptplatine/D1: U1.22 (P11), U6.5 (A2), U12.3 (B), X3.15, X4.15, X5.15, X6.15
/Hauptplatine/D2: U1.23 (P12), U6.7 (A3), U12.4 (C), X3.14, X4.14, X5.14, X6.14
/Hauptplatine/D3: U1.24 (P13), U6.9 (A4), U12.5 (D), X3.13, X4.13, X5.13, X6.13
/Hauptplatine/D4: U1.25 (P14), U6.22 (A8), U8.3 (O1), U13.2 (A), X3.12, X4.12, X5.12, X6.12
/Hauptplatine/D5: U1.26 (P15), U6.20 (A7), U8.5 (O2), U13.3 (B), X3.11, X4.11, X5.11, X6.11
/Hauptplatine/D6: U1.27 (P16), U6.18 (A6), U8.11 (O6), U13.4 (C), X3.10, X4.10, X5.10, X6.10
/Hauptplatine/D7: U1.28 (P17), U6.16 (A5), U8.13 (O5), U13.5 (D), X3.9, X4.9, X5.9, X6.9
/Hauptplatine/S0: R8.1, U8.2 (I1), X71.1
/Hauptplatine/S1: R11.1, U8.4 (I2), X71.2
/Hauptplatine/S2: R10.1, U8.12 (I6), X71.3
/Hauptplatine/S3: R9.1, U8.14 (I5), X71.4
BAS: D1.1 (K), D2.1 (K), X8.1
FF_SYNC: C6.1, R5.1, R6.2, U11.4 (S1), U11.13 (R2)
GND: C1.2, R6.1, U1.11 (GND), U5.8 (GND), U6.11 (STB), U6.12 (GND), U8.6 (I3), U8.8 (GND), U8.10 (I4), U9.7 (GND), U10.7 (GND), U11.7 (GND), U12.7 (GND), U13.7 (GND), X3.25, X4.25, X5.25, X6.25, X8.2, X9.2, X72.5; also elsewhere on the board
unnamed: C6.2, U9.12 (A4), U9.13 (B4), U10.8 (Y)
unnamed: D1.2 (A), R4.1, U1.4 (P37), X2.16
unnamed: D2.2 (A), R7.2
unnamed: Q1.1, R3.1, U9.1 (A1), U9.2 (B1)
unnamed: R3.2, U9.3 (Y1), U9.4 (A2), U9.5 (B2)
unnamed: R7.1, U13.10 (QD)
unnamed: U1.5 (P30), X2.9
unnamed: U1.9 (~AS), U6.1 (~S1)
unnamed: U1.10 (P35), X2.14
unnamed: U1.12 (P32), X2.11
unnamed: U1.30 (P33), X2.12
unnamed: U1.31 (P20), X2.1
unnamed: U1.32 (P21), X2.2
unnamed: U1.33 (P22), X2.3
unnamed: U1.34 (P23), X2.4
unnamed: U1.35 (P24), X2.5
unnamed: U1.36 (P25), X2.6
unnamed: U1.37 (P26), X2.7
unnamed: U1.38 (P27), X2.8
unnamed: U1.39 (P31), X2.10
unnamed: U1.40 (P36), X2.15
unnamed: U9.8 (Y3), U10.11 (G)
unnamed: U11.9 (Q2), U12.8 (T2), U12.9 (T1), U13.8 (T2), U13.9 (T1)
unnamed: U11.2 (D1), U11.6 (/Q1), U11.11 (T2)
unnamed: U11.8 (/Q2), U11.12 (D2)
unnamed: U9.11 (Y4), U12.6 (MC), U13.6 (MC)
unnamed: U12.10 (QD), U13.1 (ES)
P34: U1.29 (P34), X2.13, X3.29, X4.29, X5.29, X6.29
R~W: U1.7 (R/~W), X3.3, X4.3, X5.3, X6.3
TAKT: Q1.2, U1.3 (XTAL1), U9.6 (Y2), U11.3 (T1)
U1: X3.26, X4.26, X5.26, X6.26, X9.3
U2: X3.27, X4.27, X5.27, X6.27, X9.4
~CS0: U5.15 (Y0), X3.2
~CS1: U5.14 (Y1), X4.2
~CS2: U5.13 (Y2), X5.2
~CS3: U5.12 (Y3), U8.1 (~CE4), U8.15 (~CE2), X6.2
~CS4: U5.11 (Y4), X6.1
~CS5: U5.10 (Y5), X5.1
~CS6: U5.9 (Y6), X4.1
~CS7: U5.7 (Y7), X3.1
~DS: U1.8 (~DS), U5.4 (~E1), U5.5 (~E2), U9.9 (A3), U9.10 (B3)
~RESET: C1.1, TP1.1, U1.6 (~RESET)

Notes on the sheet:
E000-FFFF Modul 1
C000-DFFF Modul 2
A000-BFFF Modul 3
8000-9FFF Modul 4
6000-7FFF Modul 4
4000-5FFF Modul 3
2000-3FFF Modul 2
0800-1FFF Modul 1
Taktgenerator
Adressdekoder
Quelle: jutecomp1.pdf S. 6/7
Adresslatch
Stromversorgung
Tastaturlatch
S/W-Videoausgang
Quelle: JU+TE 07/1987, Seite 550-553
U1 und U2 Stützspannung für Zusatzspeicher ggf. auf 5V legen

Schematic: Tiny2k-Stromversorgung.sch, JU+TE TINY 2k

Parts:
C2: 22µF/16V; CP_Radial_D6.3mm_P2.50mm
C5: 2200µF/10V; CP_Axial_L25.0mm_D10.0mm_P35.00mm_Horizontal
C7, C8, C9, C10, C11: 10nF; C_Disc_D4.3mm_W1.9mm_P5.00mm
D3: 1PM05; Diode_Bridge_Round_D9.8mm
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
HS1: Kühlkörper; Heatsink_Aavid-TV5G_TO220_Horizontal
R1: 180; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
R2: 560; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
U14: B3170V; TO-220-3_Horizontal_TabDown
X1: AC: 8V/800mA; TerminalBlock_RND_205-00001_1x02_P5.00mm_Horizontal

Connections:
+5P: C2.1, C7.1, C8.1, C9.1, C10.1, C11.1, R1.2, U14.2 (VO); also elsewhere on the board
GND: C2.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, D3.1, R2.1; also elsewhere on the board
unnamed: C5.1, D3.3, U14.3 (VI)
unnamed: D3.2, X1.2
unnamed: D3.4, X1.1
unnamed: R1.1, R2.2, U14.1 (ADJ)

Notes on the sheet:
Quelle: jutecomp1.pdf S. 9
Quelle: JU+TE 08/1987, Seite 632-653
alternativ: DC: 10V/550mA
min. 50 mm^2 Kühlfläche
bei 12V Trafo: C2 auf 1000µF/16V ändern und stärkere Kühlung für U14 vorsehen

Board: 2 copper layers, 142.0 x 160.0 mm, 49 parts (0 on the bottom side), 78 nets.
