# Repository boert/JU-TE-Computer (continued)

## KiCad design Erweiterungen/Speichermodul_Typ_D/Speichermodul_Typ_D.kicad_pcb

Parts:
C3: 22nF; C_Disc_D4.3mm_W1.9mm_P5.00mm
U3: U2716; DIP-24_W15.24mm_Socket
X10: Sp.-Modul; PinHeader_1x29_P2.54mm_Horizontal

Connections:
+5P: C3.1, U3.21 (Upp), U3.24 (Udd), X10.28
/A0: U3.8 (A0), X10.17
/A1: U3.7 (A1), X10.18
/A2: U3.6 (A2), X10.19
/A3: U3.5 (A3), X10.20
/A4: U3.4 (A4), X10.21
/A5: U3.3 (A5), X10.22
/A6: U3.2 (A6), X10.23
/A7: U3.1 (A7), X10.24
/A8: U3.23 (A8), X10.4
/A9: U3.22 (A9), X10.5
/A10: U3.19 (A10), X10.6
/D0: U3.9 (D0), X10.16
/D1: U3.10 (D1), X10.15
/D2: U3.11 (D2), X10.14
/D3: U3.13 (D3), X10.13
/D4: U3.14 (D4), X10.12
/D5: U3.15 (D5), X10.11
/D6: U3.16 (D6), X10.10
/D7: U3.17 (D7), X10.9
/~CSB: U3.18 (~CE), U3.20 (~OE), X10.2
GND: C3.2, U3.12 (Uss), X10.25

Notes on the sheet:
2 kByte EPROM-Speicher
Quelle: jutecomp2.pdf S.32
EPROM 2 für 4k-System
Quelle: JU+TE 3/1989

Board: 2 copper layers, 76.0 x 36.0 mm, 3 parts (0 on the bottom side), 22 nets.

## Commit log

2021-07-26 initiale Version
2021-08-15 Doku präzisiert
2021-08-27 Speichervarianten bzw. Belegung ergänzt
2021-10-26 Tiny 6k Videoerweiterung (Schaltplan) ergänzt
2021-10-26 Schaltplan annotiert
2021-11-23 Hauptprozessor und Speichermodul ergänzt, komplette Überarbeitung
2021-11-24 Dateien umbenannt
2021-11-25 Ausbaustufen Video präzisiert
2021-11-25 Videomodul vollständig
2021-11-25 Stückliste ergänzt
2021-11-25 csv-Stückliste ergänzt
2021-11-27 C200 korrigiert, Footprints ergänzt
2021-12-04 Verzeichnisse umbenannt
2021-12-04 Reorgansiation, tlw. Layouts ergänzt, Fehlerkorrektur
2021-12-05 RAM-Stütze ergänzt (Schaltplan)
2021-12-05 EPROM-Programmierzusatz (Schaltplan) ergänzt
2021-12-05 Magnetbandinterface 4k-System (Schaltplan) ergänzt
2021-12-05 Referenz korrigiert
2021-12-05 S3004-Interface (Schaltplan) ergänzt
2021-12-05 pdf von Platinen ergänzt
2021-12-06 umbennant
2021-12-06 V.24-Schnittstelle (Schaltplan) ergänzt
2021-12-06 IFSS (Schaltplan) ergänzt
2021-12-06 EFS-Stecker korrigiert
2021-12-06 AD-Wandler (Schaltplan) ergänzt
2021-12-06 Magnetbandanschluss (Platine) hinzugefügt, PDFs umbenannt
2021-12-06 Zeilenumbruch korrigiert
2021-12-07 Bestückhilfe ergänzt
2021-12-07 Format korrigiert
2021-12-08 Videoerweiterung ergänzt (Schaltplan)
2021-12-11 ROMs für 2k-System ergänzt
2021-12-11 Bild hinzugefügt, README sortiert
2021-12-11 präzisiert
2021-12-13 Übersichtlichkeit erhöht
2021-12-13 Vcc Anschluss am RAM korrigiert
2021-12-13 aktualisiert
2021-12-14 Kommentar zur Spannungsversorgung
2021-12-14 Platine für Tastatur ergänzt
2021-12-14 Platine für Magnetbandinterface 4k-System ergänzt
2021-12-14 Kommentar ergänzt
2021-12-14 S3004-Interface präzisiert (und annotiert)
2021-12-17 Portübersicht ergänzt
2021-12-17 Portübersicht erweitert
2021-12-17 formatierung
2021-12-20 Platine für Videomodul ergänzt
2022-01-22 Bilder für Speichermodule ergänzt/aktualisiert
2022-01-22 Zeilenumbruch
2022-02-01 Videoerweiterung 2021 hinzugefügt
2022-02-01 weitere ROM-Inhalte ergänzt
2022-02-01 kleinere Korrekturen
2022-02-05 Bilder Magnetbandinterface ergänzt
2022-02-05 Bilder Videoerweiterung ergänzt
2022-02-05 R20 gedreht
2022-05-12 add: missing cache libs
2022-05-12 resort: table
2022-05-12 add: more missing cache libs
2022-05-21 .gitignore: add *-cache.lib
2022-05-21 Tiny6k_Steuerung_Video-RAM.sch: fix wires
2022-05-21 Tiny6k_*.sch: fix SC236
2023-12-13 PCB korrigiert
2024-01-21 change: add diodes on keyboard column lines, resolve #1
2025-12-10 add Wikipedia link
