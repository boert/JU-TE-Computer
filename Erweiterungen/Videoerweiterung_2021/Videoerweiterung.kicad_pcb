# Repository boert/JU-TE-Computer

File README.md:

# JU+TE-Computer
Schaltpläne und z.T. Layouts für den JU+TE Computer

## JU+TE Tiny (2k-System)
Da vom JU+TE Computer kein zusammenhängender Schaltplan existierte, wurde er mit KiCAD erstellt.
Dieser Schaltplan wurde mit dem existierenden Layout verknüpft.
Schaltplan und Layout sind konsistent.

Für den Minimalbetrieb sind ein Speichermodul (Typ A, B oder C) und eine Tastatur erforderlich.

## Erweiterungen zum JU+TE

### Speichermodul Typ A (2 kByte EPROM, 1 bis 8 kByte RAM) 
<p align="center">
  
&nbsp;
  
</p>
RAM erweiterbar bis auf 8 kByte durch zusätzliche U214 (Huckepack).
Für das 2k-System oder als unterer ROM für das 4k-System geeignet.<br>
Beim abgebildeten Modul wurde der RAM auf 2 kByte aufgestockt.
Bei mehr als 1 kByte RAM wird ein Adressdekoder DS8205D benötigt.

### Speichermodul Typ B (2 kByte EPROM, 2 bis 8 kByte RAM)
<p align="center">
  
&nbsp;
  
</p>
RAM erweiterbar bis auf 8 kByte durch zusätzliche U6516 (Huckepack).
Für das 2k-System oder als unterer ROM für das 4k-System geeignet.
Bei mehr als 2 kByte RAM wird ein Adressdekoder DS8205D benötigt.

### Speichermodul Typ C (8 kByte EPROM, 8 kByte RAM)
<p align="center">
  
&nbsp;
  
</p>
Für alle Ausbaustufen geeignet. Wenn das 2k-System oder das 4k-System in einen U2764 (8 kByte EPROM) gebrannt werden, muss das System ab Offset 0800h stehen.
Mit vier dieser Module läßt sich ein Vollausbau des Speichers realisieren (32 kByte RAM, 30 kByte EPROM).
Auch als Videospeicher für die Videoerweiterung nutzbar. In diesem Fall wird der EPROM nicht benötigt.

### Speichermodul Typ D (2 kByte EPROM)
<p align="center">
  
&nbsp;
  
</p>
Das Modul wird nur als Ergänzungsspeicher für das 4k-System benötigt, falls Modul A oder Modul B schon vorhanden sind.

### RAM-Stütze
Dient dem Erhalt des RAM-Inhaltes im ausgeschalteten Zustand für Module mit CMOS-Schaltkreisen (U224, U6516 oder HM6264LP).
Mit verbesserter Reset-Schaltung. Die Reset-Schaltung nutzt die ~9V vom Ladekondesator.

### Magnetbandanschluss
<p align="center">
  
&nbsp;
  
</p>
Damit lassen sich BASIC-Programme auf Band sichern und wieder zurücklesen.
Das Verfahren ist relativ einfach: Die Binärdaten werden über die SIO (Port P3.7) ausgegeben und mit 4,8 kHz vom Port P3.6 moduliert.
Es wird direkt der Speicherinhalt ausgegeben. Es gibt keine Fehlererkennung bzw. -korrektur, kein Dateiname und keine Adressinformation.
Die Schaltung läßt sich optimieren, indem der Pull-Up-Widerstand zwischen OPV (B761) und Inverter (B555) auf z.B. 8 kOhm reduziert wird.
Damit wird das Puls-/Pausverhältnis korrigiert.
Mit anderen Varianten des Magnektbankinterfaces (4k-System, 6k-System) läßt sich am 2k-System nichts mehr abspeichern, da dort der Modulator (DL000) fehlt.

### Magnetbandinterface 4k-System
<p align="center">
  
&nbsp;
  
</p>
Weiterentwickeltes Magnetband-Interface für das 4k-System, zusätzlich mit integriertem Videosignalinverter.
Im 4k-System wird ein anderes Aufzeichnungsformat verwendet: Es gibt Trennzeichen (600 Hz), 0-Bits (1200 Hz) und 1-Bits (2400 Hz). Das Format entsprich dem des KC85 und enthält Dateinamen, Ladeadresse und Prüfsummen.

### Tastatur
Schaltungsvorschlag für eine 4x12 Matrixtastatur.

### Videoinverter
Ändert die Polarität des Videosignals und erzeugt ein BAS-Signal.
Die Originalschaltung ist sehr empfindlich. Robuster ist die Variante, die auf dem 4k-Magnetbandinterface realisiert ist. 

### UHF-Modulator
Mischt das BAS-Signal auf TV-Kanal 36. Die Erweiterung wird hier nicht weiter beschrieben.

### EPROM-Programmierzusatz
Erweiterung des JU+TE zum EPROM-Programmiergerät für die Typen U2716, U2764 und U27128.

### S3004-Interface
Potentialgetrennte Schnittstelle für die elektronische Schreibmaschine Erika S3004.
Nutzung der Schreibmaschine als Drucker.
Da der Rückkanal nicht verwendet wird, kann die Schreimaschine nicht als Tastatur genutzt werden.

### V.24-Interface
Pegelwandlerstufe zur Kopplung mit seriellen Perioheriegeräten (z.B. Drucker) oder zur Rechnerkopplung.
Die Interfaceschaltung nutzt die 9V-Spannung vom Ladekondensator.

### IFSS-Interface
Schnittstelle nach dem Prinzip der gekoppelten Stromschleifen, IFSS (Interface seriell sternförmig).
Das IFSS-Interface benötigt die 9V-Spannung vom Ladekondensator.

### AD-Wandler
Zur Messung von Spannungen zwischen 0 und 999 mV.

### Videoerweiterung

Damit wird die Videosignalerzeugung von einem separaten Prozessor (UB8810, UB8830 oder UB8860) übernommen.
Der Bildspicher wird im Bereich zwischen %4000 und %5FFF im System eingeblendet.
Über Steuerregister (Adressen %6000-%63FF) wird festgelegt, auf welche Speicherebenen des Videospeicher zugegriffen wird.

Die mögliche Bildschirmauflösung und die nutzbare Farbtiefe hängt vom Speicherausbau ab:

Speichermodule | Video-RAM | Auflösung | Farbtiefe
-------------- | --------: | :-------: | ---------
1              | 8 kByte   |  320x192  | s/w
2              | 16 kByte  |  640x192  | s/w
4              | 32 kByte  |  320x192  | 16 Farben   
4              | 32 kByte  |  640x192  | 8 Farben

Ob es Software gibt, welche die hochauflösenden 640x192 Pixel-Modi nutzt, entzieht sich meiner Kenntniss.
Die Installation der Videoerweiterung erfordert die Verdrahtung zusätzlicher Signale, die nicht am Modulsteckplatz anliegen: TAKT, /CS3, KEY und BUSY

## JU+TE Kompakt (6k-System)
Im JU+TE Kompakt sind die Videoerweiterung, das Magnetbandinterface (4k-Version), 32 kByte RAM, die RAM-Stütze und 8 kByte EPROM integriert.
Um die Videoerweiterung zu nutzen wird im EPROM das 6k-System eingespielt.

## Nutzung der frei verfügbaren Ports

| Ports                               | P2.0 | P2.1 | P2.2 | P2.3 | P2.4 | P2.5 | P2.6 | P2.7 | P3.0 | P3.1 | P3.2 | P3.3 | P3.4 | P3.5 | P3.6 | P3.7     |
| ----------------------------------- |:----:|:----:|:----:|:----:|:----:|:----:|:----:|:----:|:----:|:----:|:----:|:----:|:----:|:----:|:----:|:--------:|
| JU+TE-Grundplatine (7/1987)         |      |      |      |      |      |      |      |      |      |      |      |      | (BS) |      |      | SYN      |
| Magnetbandinterface (2k, 12/1987)   |      |      |      |      |      |      |      |      | LOAD |      |      |      |      |      | SAVE | Umschalt |
| Lauflicht (4/1988)                  | LED  | LED  | LED  | LED  | LED  | LED  | LED  | LED  |      |      |      |      |      |      |      |          |
| EPROM-Programmierzusatz (10/1988)   | A+D  | A+D  | A+D  | A+D  | A+D  | A+D  | A+D  | A+D  |      |      |      |      | CTRL | CTRL | CTRL |          |
| Magnetbankinterface (4k, 3/1989)    |      |      |      |      |      |      |      |      | LOAD |      |      |      |      |      | SAVE |          |
| S3004-Interface (HW-SIO, 5/1989)    |      |      |      |      |      |      |      |      |      |      |      |      |      |      |      | TxD      |
| S3004-Interface (SW, 5/1989)        |      |      |      |      |      |      |      |      |      | DSR  |      |      |      | TxD  |      |          |
| IFSS-Inferface (10/1989)            |      |      |      |      |      |      |      |      | E    |      |      |      |      |      |      | S        |
| V.24-Interface (HW-SIO, 10/1989)    |      |      |      |      |      |      |      |      | RxD  |      |      |      |      |      |      | TxD      |
| V.24-Interface (SW, K6340, 10/1989) |      |      |      |      |      |      |      |      |      | DSR  |      |      |      | TxD  |      |          |
| Streifenkorrektur (11/1989)         |      |      |      |      |      |      |      |      |      |      |      |      |      | VSYN |      |          |
| AD-Wandler (12/1989)                | QA   | QB   | QC   | QD   | NSD  | MSD  | ISD  |      |      |      |      |      |      |      |      |          |
| Magnetbankinterface (ES4.0, 1990)   |      |      |      |      |      |      |      |      | LOAD |      |      |      |      |      | SAVE |          |
| Videoerweiterung (6/1990)           |      |      |      |      |      |      |      |      |      |      | BUSY |      | /HR  |      |      |          |
| ROM-Bank (ES4.0, 2019)              |      |      |      |      |      |      |      |      |      |      |      |      |      | /BR  |      | STEP     |
| ROM-Bank (ES1988, 10/2021)          |      |      |      |      |      |      |      |      |      |      |      |      |      | STEP |      |          |
|                                     |      |      |      |      |      |      |      |      |      |      |      |      |      |      |      |          |

Legende:  
A+D = Adresse und Daten  
BR = bank reset, Bank zurücksetzen  
BS = bank switch, Bankumschaltung, bisher keine Nutzung bekannt  
BUSY = Zugriff ohne Bildstörung  
CTRL = Steuerleitung  
DSR = Dataset Read, Empfangsbereitschaft  
E = Empfang  
HR = high resolution, Umschaltung Grafikmodus  
RxD = Empfangsdaten  
S = Senden  
STEP = Bank weiterschalten  
SYN = Synchronsignal für Video  
TxD = Sendedaten  
VSYN = Zeilensynchronisierung  

## Quellen  
https://hc-ddr.hucki.net/wiki/lib/exe/fetch.php/tiny/jutecomp1.pdf  
https://hc-ddr.hucki.net/wiki/lib/exe/fetch.php/tiny/jutecomp2.pdf  
https://hc-ddr.hucki.net/wiki/lib/exe/fetch.php/tiny/jutecomp3.pdf 

## Wikipedia
https://de.wikipedia.org/wiki/Ju-Te-Computer

## KiCad design Erweiterungen/Videoerweiterung_2021/Videoerweiterung.kicad_pcb

File Erweiterungen/Videoerweiterung_2021/README.md:

# JU+TE Videoerweiterung, 2021

Mit der Videoerweiterung läßt sich das Grundsystem zum 6k-System erweitern.

## Voraussetzungen
Folgende Voraussetzungen sind dafür zu erfüllen:
- im Steckplatz 1 (/CS0, /CS7) muß der EPROM mit dem 6k-System stecken
- im Steckplatz 1 müssen 8 kByte RAM bestückt sein
- im Steckplatz 4 wird die Videoerweiterung gesteckt
- ggf. muß eine angepasste Tastatur verwendet werden
- die Zusatzverbindungen für Takt, /CS2, /KEY und BUSY sind herzustellen
- es wird ein Bildschirm mit SCART-Eingang und ein entprechendes Adapterkabel benötigt

## Veränderungen gegenüber der Originalplatine
Die Version 2021 der Videoerweiterung enthält gegenüber dem Original von 1990 folgende Veränderungen:
- Videobuchse (DIN 5-polig) inklusive der nötigen Widerstände integriert;
  es passt das SCART-Adapterkabel vom Z9001
- Verbindungen zur Hauptplatine (Takt, /CS2, BUSY und /KEY) auf einer Steckleiste zusammengefasst
- BUSY-Signal zum Rand geführt
- Jumper für Umschaltsignal (high resolution) /HR ergänzt (Auswahl: low, high oder P3.4)
- am Videomultiplexer wurden Jumper für die Signale B und V ergänzt
- Jumper W hinzugefügt, um den Widerstandswert von R36 anpassen zu können (6,8 kOhm bzw. 2,2 kOhm)
- Jumper für SYN-Signal hinzugefügt
- frei Flächen mit 00 (GND) gefüllt
- Workaround für Timingprobleme ergänzt: R212 (1,5k) und VD203 (SAY32), Beschreibung in jutecomp3.pdf (Seite 46, Mitte unten)
- Massepunkt hinzugefügt (erleichtert die Fehlersuche)

## Belegung der Videobuchse (DIN 5-polig)
Pin    | Signal
------ | ------
1      | Grün
2      | Blau
3      | Synchronsignal bzw. BAS
4      | Rot
5      | Umschaltsignal /AV-RGB
Schirm | GND

Die Beschreibung eines passenden SCART-Kabels ist bei Ulrich Zander zu finden:
https://www.sax.de/~zander/z9001/tp.html#TV

## Anpassungen an der Grundplatine
Die Stromaufnahme der Videoerweiterung beträgt (ohne Video-RAM-Module) ca. 800 mA.
Damit ist der Spannungsregler der Grundplatine (B3170V) überfordert.
Es ist eine separate Einspeisung von geregelten 5V über die Videoerweiterung nötig.
Zum Schutz des B3170V (Spannung am Ausgang ggf. höher, als am Eingang) wird eine Diode zwischen Pin 2 (Ausgang, Anode) und Pin 3 (Eingang, Kathode) plaziert.

Für den Speicherbereich zwischen %6000 und %7FFF gibt es einen separaten Adressdekoder auf der Videoerweiterung. Damit neben der Bildschirmsteuerung die Tastatur weiterhin funktioniert, muß das /CS3-Signal zum Tastaturlatch (V40098D, Pin 1 und 15) aufgetrennt werden. Die Tastatur bekommt ihr Auswahlsignal (/KEY) nun von der Videoerweiterung.
Ein Rückbau ist durch Einsatz einer Steckbrücke möglich.

Der Videospeicher (VRAM) wird im Bereich %4000 bis %5FFF eingeblendet und benötig dazu das /CS2-Signal vom Steckplatz 3.

Außerdem wird noch der Systemtakt benötigt. Dieser läßt sich direkt nebem dem Taktgenerator abgreifen.

Das BUSY-Signal kann über einen 100 kOhm-Widerstand mit Port P3.2 der Haupt-CPU verbunden werden.

Wenn man alle zusätzlich Signale auf eine separate Buchsenleiste führt, ist der Einbau und auch der Rückbau der Videoerweiterung schnell und unkompliziert.

## Änderungen an der Grundplatine (Kurzform)
- Schutzdiode für B3170V einbauen
- Auftrennung /CS3, Steckbrücke für den Betrieb ohne Videoerweiterung ergänzen
- /CS2-Signal vom vorletzten Steckplatz verdrahten
- Systemtakt anschließen
- optional BUSY über 100 kOhm mit P3.2 verbinden

## Einbausituation

Die senkrechte Montage hat den Nachteil, das hohe Speichermodule - wie der Typ C - die Modulsteckplätze 2 und 3 blockieren. Mit niedrigeren Speichermodulen oder einer waagerechten Montage (andere Steckverbinder) umgeht man das Problem.

## Quellen
https://hc-ddr.hucki.net/wiki/lib/exe/fetch.php/tiny/jutecomp3.pdf  
https://hc-ddr.hucki.net/wiki/doku.php/tiny/nachbauten

Board: 2 copper layers, 141.5 x 160.0 mm, 143 parts (2 on the bottom side), 170 nets.

Parts:
C1, C6, C11, C16, C21: 33pF; C_Disc_D5.0mm_W2.5mm_P2.50mm
C2: 220µF/16V; CP_Axial_L25.0mm_D10.0mm_P30.00mm_Horizontal
C3, C19, C22: 100nF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C4, C5, C7, C8, C9, C10, C12, C13, C14, C15, C17, C20, C24: 22nF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C18: 22nF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C23: 47µF/10V; CP_Radial_D8.0mm_P5.00mm
C200: 33pF; C_Disc_D4.7mm_W2.5mm_P5.00mm
C201: 1µF; CP_Radial_D5.0mm_P2.50mm
C202: 220p; C_Disc_D5.0mm_W2.5mm_P5.00mm
D0: DL253D; DIP-16_W7.62mm_Socket
D1, D4, D9, D12: DL299D; DIP-20_W7.62mm_Socket
D2, D8, D15, D17: DL540D; DIP-20_W7.62mm_Socket
D3, D7, D11, D16: DS8286D; DIP-20_W7.62mm_Socket
D5: DS8212D; DIP-24_W15.24mm_Socket
D6: U2716; DIP-24_W15.24mm_Socket
D10, D21: DL257D; DIP-16_W7.62mm_Socket
D13: UB8860; DIP-40_W15.24mm_Socket
D14, D18: DL295D; DIP-14_W7.62mm_Socket
D19: DL004D; DIP-14_W7.62mm_Socket
D20: DS8205D; DIP-16_W7.62mm_Socket
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_DIN965
JP501: HR_high; PinHeader_1x02_P2.54mm_Vertical
JP502: V; PinHeader_1x02_P2.54mm_Vertical
JP503: HR_P34; PinHeader_1x02_P2.54mm_Vertical
JP504: HR_low; PinHeader_1x02_P2.54mm_Vertical
JP505: W; PinHeader_1x02_P2.54mm_Vertical
JP506: SYN; PinHeader_1x02_P2.54mm_Vertical
JP507: B; PinHeader_1x02_P2.54mm_Vertical
LOGO1, LOGO2, LOGO2#2: jute_pcb_logo
R2, R3, R7, R8, R12, R13, R17, R18, R22, R23: 1k; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical
R4, R9, R14, R19, R24: 2,2k; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical
R5, R10, R15, R25: 220; R_Axial_TGL8728_L5.9mm_D2.4mm_P12.50mm_Horizontal
R20, R402, R403, R404: 220; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical
R26: 6,8k; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical
R200, R202: 4,7k; R_Axial_TGL8728_L5.9mm_D2.4mm_P12.50mm_Horizontal
R201: 1k; R_Axial_TGL8728_L5.9mm_D2.4mm_P12.50mm_Horizontal
R203, R207, R208, R209, R210, R211: 470; R_Axial_TGL8728_L5.9mm_D2.4mm_P12.50mm_Horizontal
R204: 8,2k; R_Axial_TGL8728_L5.9mm_D2.4mm_P12.50mm_Horizontal
R205: 1,2k; R_Axial_TGL8728_L5.9mm_D2.4mm_P12.50mm_Horizontal
R206: 6,2k; R_Axial_TGL8728_L5.9mm_D2.4mm_P12.50mm_Horizontal
R212: 1,5k; R_Axial_TGL8728_L5.9mm_D2.4mm_P12.50mm_Horizontal
R401: 51; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical
R405, R408, R409: 160; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical
R406: 100; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical
R407: 75; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical
R501: 3,3k; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical
TP201: 00; PinHeader_1x01_P2.54mm_Vertical
TP400: V; PinHeader_1x01_P2.54mm_Vertical
TP401: B; PinHeader_1x01_P2.54mm_Vertical
TP402: S; PinHeader_1x01_P2.54mm_Vertical
TP403: G; PinHeader_1x01_P2.54mm_Vertical
TP404: R; PinHeader_1x01_P2.54mm_Vertical
VD200, VD202, VD203, VD400, VD401, VD402, VD403, VD404, VD405: SAY32; D_E-Line_P2.5mm_Vertical
VD201: SZX21/7.5; D_DO-34_SOD68_P2.54mm_Vertical_KathodeUp
VT200: SC308; T_E-Line_Wide_P2.5mm_Vertical
VT201, VT400, VT401, VT402, VT403, VT404: SC236; T_E-Line_Wide_P2.5mm_Vertical
X200: Bus; PinHeader_1x29_P2.54mm_Horizontal
X201: ~{CS2}; PinHeader_1x01_P2.54mm_Horizontal
X202: XTAL; PinHeader_1x02_P2.54mm_Horizontal
X203: select; PinHeader_1x06_P2.54mm_Vertical
X204: ~{KEY}; PinHeader_1x01_P2.54mm_Horizontal
X205: BUSY; PinHeader_1x01_P2.54mm_Horizontal
X206: POWER; SolderWire-0.75sqmm_1x02_P4.8mm_D1.25mm_OD2.3mm
X300, X301, X302, X303: 8k RAM-Modul; PinSocket_1x29_P2.54mm_Vertical
X401: DIN-5_180degree; DIN-Buchse_5polig_halbrund_Print_erweitert
X405: 00; PinHeader_1x01_P2.54mm_Vertical

Connections:
+5V: C2.1, C3.1, C4.1, C5.1, C7.1, C8.1, C9.1, C10.1, C12.1, C13.1, C14.1, C15.1, C17.1, C18.1, C19.1, C20.1, C22.1, C23.1, C24.1, D0.16, D1.1, D1.2, D1.3, D1.9, D1.18, D1.20, D2.20, D3.20, D4.1, D4.2, D4.3, D4.9, D4.18, D4.20, D5.2, D5.13, D5.14, D5.24, D6.21, D6.24, D7.20, D8.20, D9.1, D9.2, D9.3, D9.9, D9.18, D9.20, D10.16, D11.20, D12.1, D12.2, D12.3, D12.9, D12.18, D12.20, D13.1, D14.8, D14.14, D15.20, D16.20, D17.20, D18.6, D18.14, D19.14, D20.6, D20.16, D21.3, D21.16, JP501.1, R3.1, R8.1, R13.1, R18.1, R23.1, R201.1, R205.1, R206.1, R207.1, R208.1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
/Scart-Ausgang/Blau: R404.2, R405.1, X401.2
/Scart-Ausgang/Grün: R402.1, R408.2, X401.1
/Scart-Ausgang/Rot: R403.2, R409.2, X401.4
/Scart-Ausgang/Sync_BAS: R401.1, R407.1, X401.3
/Scart-Ausgang/~AVRGB: R406.1, X401.5
/Steuerung Video-RAM/VBD0: D9.7, D11.4, X302.12
/Steuerung Video-RAM/VBD1: D9.13, D11.8, X302.16
/Steuerung Video-RAM/VBD2: D9.6, D11.3, X302.11
/Steuerung Video-RAM/VBD3: D9.14, D11.7, X302.15
/Steuerung Video-RAM/VBD4: D9.5, D11.2, X302.10
/Steuerung Video-RAM/VBD5: D9.15, D11.6, X302.14
/Steuerung Video-RAM/VBD6: D9.4, D11.1, X302.9
/Steuerung Video-RAM/VBD7: D9.16, D11.5, X302.13
/Steuerung Video-RAM/VGD0: D4.7, D7.4, X303.12
/Steuerung Video-RAM/VGD1: D4.13, D7.8, X303.16
/Steuerung Video-RAM/VGD2: D4.6, D7.3, X303.11
/Steuerung Video-RAM/VGD3: D4.14, D7.7, X303.15
/Steuerung Video-RAM/VGD4: D4.5, D7.2, X303.10
/Steuerung Video-RAM/VGD5: D4.15, D7.6, X303.14
/Steuerung Video-RAM/VGD6: D4.4, D7.1, X303.9
/Steuerung Video-RAM/VGD7: D4.16, D7.5, X303.13
/Steuerung Video-RAM/VRD0: D1.7, D3.4, X301.12
/Steuerung Video-RAM/VRD1: D1.13, D3.8, X301.16
/Steuerung Video-RAM/VRD2: D1.6, D3.3, X301.11
/Steuerung Video-RAM/VRD3: D1.14, D3.7, X301.15
/Steuerung Video-RAM/VRD4: D1.5, D3.2, X301.10
/Steuerung Video-RAM/VRD5: D1.15, D3.6, X301.14
/Steuerung Video-RAM/VRD6: D1.4, D3.1, X301.9
/Steuerung Video-RAM/VRD7: D1.16, D3.5, X301.13
/Steuerung Video-RAM/VVD0: D12.7, D16.4, X300.12
/Steuerung Video-RAM/VVD1: D12.13, D16.8, X300.16
/Steuerung Video-RAM/VVD2: D12.6, D16.3, X300.11
/Steuerung Video-RAM/VVD3: D12.14, D16.7, X300.15
/Steuerung Video-RAM/VVD4: D12.5, D16.2, X300.10
/Steuerung Video-RAM/VVD5: D12.15, D16.6, X300.14
/Steuerung Video-RAM/VVD6: D12.4, D16.1, X300.9
/Steuerung Video-RAM/VVD7: D12.16, D16.5, X300.13
/Videoausgabe/b: D0.9, JP507.2, R19.2
/Videoausgabe/v: D0.7, JP502.2, JP505.1, R26.2
/Videoausgabe/~HR: D0.2, JP501.2, JP503.1, JP504.1
/Videoprozessor/6C00h-6FFFh: D20.12, X203.3
/Videoprozessor/7C00h-7FFFh: D20.7, X204.1
/Videoprozessor/6000h-63FFh: D18.9, D20.15
/Videoprozessor/6400h-67FFh: D20.14, X203.1
/Videoprozessor/6800h-6BFFh: D20.13, X203.2
/Videoprozessor/7000h-73FFh: D20.11, X203.4
/Videoprozessor/7400h-77FFh: D20.10, X203.5
/Videoprozessor/7800h-7BFFh: D20.9, X203.6
/Videoprozessor/A0: D15.9, X200.17
/Videoprozessor/A1: D15.8, X200.18
/Videoprozessor/A2: D15.7, X200.19
/Videoprozessor/A3: D15.6, X200.20
/Videoprozessor/A4: D15.5, D18.2, X200.21
/Videoprozessor/A5: D15.4, D18.3, X200.22
/Videoprozessor/A6: D15.3, D18.4, X200.23
/Videoprozessor/A7: D15.2, D18.5, X200.24
/Videoprozessor/A8: D17.6, X200.4
/Videoprozessor/A9: D17.5, X200.5
/Videoprozessor/A10: D17.4, D20.1, X200.6
/Videoprozessor/A11: D17.3, D20.2, X200.7
/Videoprozessor/A12: D17.2, D20.3, X200.8
/Videoprozessor/BUSY: D13.40, X205.1
/Videoprozessor/VA0: D2.6, D5.4, D6.8
/Videoprozessor/VA1: D2.7, D5.6, D6.7
/Videoprozessor/VA2: D2.8, D5.8, D6.6
/Videoprozessor/VA3: D2.9, D5.10, D6.5
/Videoprozessor/VA4: D2.3, D5.21, D6.4
/Videoprozessor/VA5: D2.4, D5.19, D6.3
/Videoprozessor/VA6: D2.5, D5.17, D6.2
/Videoprozessor/VA7: D5.15, D6.1
/Videoprozessor/VA8: D6.23, D13.13
/Videoprozessor/VA9: D6.22, D13.14
/Videoprozessor/VA10: D6.19, D13.15
/Videoprozessor/VAD0: D5.3, D6.9, D13.21
/Videoprozessor/VAD1: D5.5, D6.10, D13.22
/Videoprozessor/VAD2: D5.7, D6.11, D13.23
/Videoprozessor/VAD3: D5.9, D6.13, D13.24
/Videoprozessor/VAD4: D5.22, D6.14, D13.25
/Videoprozessor/VAD5: D5.20, D6.15, D13.26
/Videoprozessor/VAD6: D5.18, D6.16, D13.27
/Videoprozessor/VAD7: D5.16, D6.17, D13.28
/Videoprozessor/VP3.7: D13.4, D14.2
/Videoprozessor/xA7: D8.7, D13.31
/Videoprozessor/xA8: D8.6, D13.32
/Videoprozessor/xA9: D8.5, D13.33
/Videoprozessor/xA10: D8.4, D13.34
/Videoprozessor/xA11: D8.3, D13.35
/Videoprozessor/xA12: D8.2, D13.36
/Videoprozessor/~VAS: D5.1, D13.9
/Videoprozessor/~VDS: D6.18, D6.20, D10.3, D10.6, D10.10, D10.13, D13.8, D13.37, D14.6
/Videoprozessor/~VRT: D13.6, R203.1, VD201.1, VT201.1
B: C16.1, R20.1, R405.2, TP401.1, VT401.3
CS2: D2.1, D2.19, D8.1, D8.19, D13.39, D19.9, D19.10
D0: D3.16, D7.16, D11.16, D16.16, X200.16
D1: D3.12, D7.12, D11.12, D16.12, X200.15
D2: D3.17, D7.17, D11.17, D16.17, X200.14
D3: D3.13, D7.13, D11.13, D16.13, X200.13
D4: D3.18, D7.18, D11.18, D16.18, X200.12
D5: D3.14, D7.14, D11.14, D16.14, X200.11
D6: D3.19, D7.19, D11.19, D16.19, X200.10
D7: D3.15, D7.15, D11.15, D16.15, X200.9
DIR: D3.11, D7.11, D11.11, D16.11, D21.4, R211.2, X300.3, X301.3, X302.3, X303.3
G: C6.1, R10.2, R408.1, TP403.1, VT403.3
GND: C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C10.2, C12.2, C13.2, C14.2, C15.2, C17.2, C18.2, C19.2, C20.2, C22.2, C23.2, C24.2, C202.1, D0.1, D0.8, D0.15, D1.10, D1.11, D2.2, D2.10, D3.10, D4.10, D4.11, D5.11, D5.12, D6.12, D7.10, D8.8, D8.9, D8.10, D9.10, D9.11, D10.8, D10.15, D11.10, D12.10, D12.11, D13.11, D13.12, D14.1, D14.3, D14.4, D14.5, D14.7, D15.10, D16.10, D17.7, D17.8, D17.9, D17.10, D18.1, D18.7, D19.7, D20.8, D21.8, D21.15, JP504.2, R5.1, R10.1, R15.1, R20.2, R25.1, R202.2, TP201.1, VD201.2, VT201.3, X200.25, X202.2, X206.2, X300.25, X301.25, X302.25, X303.25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
unnamed: C1.2, R2.1, R3.2
unnamed: C6.2, R7.1, R8.2
unnamed: C11.2, R12.1, R13.2
unnamed: C16.2, R17.1, R18.2
unnamed: C21.2, R22.1, R23.2
unnamed: C200.1, R204.1, VT201.2
unnamed: C200.2, D19.6, R200.2, R204.2
unnamed: C201.1, R203.2, VD200.1
unnamed: C201.2, R202.1, VT200.1
unnamed: C202.2, D18.8, R206.2, VD202.2
unnamed: D13.3, D19.12, R205.2
unnamed: D15.1, D17.1, R212.1, VD203.1
unnamed: D19.1, X202.1
unnamed: D19.4, VD202.1
unnamed: JP505.2, R501.2
unnamed: JP506.1, R24.2
unnamed: R2.2, VD405.2, VT404.2
unnamed: R4.1, VD405.1
unnamed: R7.2, VD404.2, VT403.2
unnamed: R9.1, VD404.1
unnamed: R12.2, VD403.2, VT402.2
unnamed: R14.1, VD403.1
unnamed: R17.2, VD402.2, VT401.2
unnamed: R19.1, VD402.1
unnamed: R22.2, VD400.2, VD401.2, VT400.2
unnamed: R24.1, VD401.1
unnamed: R26.1, R501.1, VD400.1
unnamed: R200.1, R201.2, VT200.2
P3.4: JP503.2, X200.29
R: C1.1, R5.2, R409.1, TP404.1, VT404.3
RT: D19.5, X200.26
R~W: D21.2, X200.3
S: C11.1, R15.2, R407.2, TP402.1, VT402.3
S1: D1.19, D4.19, D9.19, D12.19, D14.10
T: D0.14, D1.12, D4.12, D9.12, D12.12, D14.9, D19.2, D19.13
V: C21.1, R25.2, R401.2, R402.2, R403.1, R404.1, TP400.1, VT400.3
VRA0: D2.14, D15.11, X300.17, X301.17, X302.17, X303.17
VRA1: D2.13, D15.12, X300.18, X301.18, X302.18, X303.18
VRA2: D2.12, D15.13, X300.19, X301.19, X302.19, X303.19
VRA3: D2.11, D15.14, X300.20, X301.20, X302.20, X303.20
VRA4: D2.17, D15.15, X300.21, X301.21, X302.21, X303.21
VRA5: D2.16, D15.16, X300.22, X301.22, X302.22, X303.22
VRA6: D2.15, D15.17, X300.23, X301.23, X302.23, X303.23
VRA7: D8.13, D15.18, X300.24, X301.24, X302.24, X303.24
VRA8: D8.14, D17.14, X300.4, X301.4, X302.4, X303.4
VRA9: D8.15, D17.15, X300.5, X301.5, X302.5, X303.5
VRA10: D8.16, D17.16, X300.6, X301.6, X302.6, X303.6
VRA11: D8.17, D17.17, X300.7, X301.7, X302.7, X303.7
VRA12: D8.18, D17.18, X300.8, X301.8, X302.8, X303.8
YB: D0.5, D0.11, D0.12, D0.13, D9.17, JP507.1
YG: D4.17, R9.2
YR: D1.17, R4.2
YV: D0.3, D0.4, D0.6, D0.10, D12.17, JP502.1
~CS2_delay: D13.38, D15.19, D17.19, D19.8
~CS2: D10.1, D19.3, D19.11, D21.1, R212.2, VD203.2, X201.1
~CS3: D20.4, D20.5, X200.2
~EB: D10.14, D11.9, D18.12, R208.2
~EG: D7.9, D10.11, D18.11, R209.2
~ER: D3.9, D10.5, D18.10, R210.2
~EV: D10.2, D16.9, D18.13, R207.2
~SB: D10.12, X302.1
~SG: D10.9, X303.1
~SR: D10.7, X301.1
~SV: D10.4, X300.1
~SYN: D13.10, JP506.2, R14.2

## KiCad design Erweiterungen/Magnetbandinterface_4k-System/Magnetbandinterface_4k-System.kicad_pcb

Parts:
C1: 10µF/25V; CP_Radial_D6.3mm_P2.50mm
C2: 100pF; C_Rect_L9.0mm_W2.5mm_P7.50mm_MKT
C3: 100pF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C13, C14: 2,7nF; C_Rect_L9.0mm_W2.5mm_P7.50mm_MKT
C16, C18: 1µF/40V; CP_Radial_D6.3mm_P2.50mm
C17: 10µF/16V; CP_Radial_D6.3mm_P2.50mm
LS1: 4-100 Ohm; TerminalBlock_RND_205-00001_1x02_P5.00mm_Horizontal
R1: 680; R_Axial_TGL8728_L5.9mm_D2.4mm_P12.50mm_Horizontal
R2, R15: 3,3k; R_Axial_TGL8728_L5.9mm_D2.4mm_P12.50mm_Horizontal
R3: 12k; R_Axial_TGL8728_L5.9mm_D2.4mm_P12.50mm_Horizontal
R4: 10k; R_Axial_TGL8728_L5.9mm_D2.4mm_P12.50mm_Horizontal
R5, R13: 330; R_Axial_TGL8728_L5.9mm_D2.4mm_P12.50mm_Horizontal
R6, R7, R8, R17, R18: 100k; R_Axial_TGL8728_L5.9mm_D2.4mm_P12.50mm_Horizontal
R14, R19: 22k; R_Axial_TGL8728_L5.9mm_D2.4mm_P12.50mm_Horizontal
T1: SC238d; TO-92_Inline_Wide
T2: SC238; TO-92_Inline_Wide
TP1: E; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP2: 00; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP3: A; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP10: L; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
U17: B555D; DIP-8_W7.62mm
U18: B761D; DIP-6_W7.62mm
X4: P3.6; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
X5: P3.0; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
X6: 00; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
X7: BAS; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
X8: Video; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
X9: 5V; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
X13: DIN-3; PinHeader_1x03_P2.54mm_Vertical

Connections:
+5P: C17.1, R1.1, R2.1, R7.1, R13.1, R15.1, R17.1, U17.4 (RES), U17.8 (Vcc), U18.1 (+), X9.1
/A: R6.2, R19.1, TP3.1, X13.1
/E: C16.2, TP1.1, X13.3
/L: C18.2, LS1.1, TP10.1
/P30: U17.3 (OUT), X5.1
/P36: R2.2, R3.2, R14.2, X4.1
GND: C2.2, C13.2, C17.2, LS1.2, R4.2, R5.2, R8.2, R18.2, R19.2, T1.1 (E), TP2.1, U17.1 (GND), U18.4 (-), X6.1, X13.2
unnamed: C1.1, X7.1
unnamed: C1.2, R1.2, T2.3 (C)
unnamed: C2.1, R5.1, T2.1 (E)
unnamed: C3.1, R7.2, R8.1, U18.3 (-)
unnamed: C3.2, R15.2, U17.2 (TRIG), U17.6 (COMP), U18.5
unnamed: C13.1, C14.2, R14.1
unnamed: C14.1, R6.1
unnamed: C16.1, R17.2, R18.1, U18.2 (+)
unnamed: C18.1, R13.2, T1.3 (C)
unnamed: R3.1, T1.2 (B)
unnamed: R4.1, T2.2 (B), X8.1

Notes on the sheet:
Quelle: jutecomp2.pdf S. 30
Quelle: JU+TE 3/1989, Seite 230-235
Signal
Videoinverter

Board: 2 copper layers, 35.0 x 47.0 mm, 36 parts (0 on the bottom side), 18 nets.

## KiCad design Erweiterungen/Tastatur/Tastatur.kicad_pcb

Parts:
C12: 10nF; C_Disc_D4.3mm_W1.9mm_P5.00mm
H1, H2, H3, H4: M3,5; MountingHole_3.5mm
SW1: CUU/CUD; TSE15_stehend_ohne_Beleuchtung
SW2: 1; TSE15_stehend_ohne_Beleuchtung
SW3: 2; TSE15_stehend_ohne_Beleuchtung
SW4: 3; TSE15_stehend_ohne_Beleuchtung
SW5: 4; TSE15_stehend_ohne_Beleuchtung
SW6: 5; TSE15_stehend_ohne_Beleuchtung
SW7: 6; TSE15_stehend_ohne_Beleuchtung
SW8: 7; TSE15_stehend_ohne_Beleuchtung
SW9: 8; TSE15_stehend_ohne_Beleuchtung
SW10: 9; TSE15_stehend_ohne_Beleuchtung
SW11: 0; TSE15_stehend_ohne_Beleuchtung
SW12: CLR; TSE15_stehend_ohne_Beleuchtung
SW13: CUL/CUR; TSE15_stehend_ohne_Beleuchtung
SW14: Q; TSE15_stehend_ohne_Beleuchtung
SW15: W; TSE15_stehend_ohne_Beleuchtung
SW16: E; TSE15_stehend_ohne_Beleuchtung
SW17: R; TSE15_stehend_ohne_Beleuchtung
SW18: T; TSE15_stehend_ohne_Beleuchtung
SW19: Z; TSE15_stehend_ohne_Beleuchtung
SW20: U; TSE15_stehend_ohne_Beleuchtung
SW21: I; TSE15_stehend_ohne_Beleuchtung
SW22: O; TSE15_stehend_ohne_Beleuchtung
SW23: P; TSE15_stehend_ohne_Beleuchtung
SW24: +; TSE15_stehend_ohne_Beleuchtung
SW25: Shift; TSE15_stehend_ohne_Beleuchtung
SW26: A; TSE15_stehend_ohne_Beleuchtung
SW27: S; TSE15_stehend_ohne_Beleuchtung
SW28: D; TSE15_stehend_ohne_Beleuchtung
SW29: F; TSE15_stehend_ohne_Beleuchtung
SW30: G; TSE15_stehend_ohne_Beleuchtung
SW31: H; TSE15_stehend_ohne_Beleuchtung
SW32: J; TSE15_stehend_ohne_Beleuchtung
SW33: K; TSE15_stehend_ohne_Beleuchtung
SW34: L; TSE15_stehend_ohne_Beleuchtung
SW35: *; TSE15_stehend_ohne_Beleuchtung
SW36: -; TSE15_stehend_ohne_Beleuchtung
SW37: Space; TSE15_stehend_ohne_Beleuchtung
SW38: Y; TSE15_stehend_ohne_Beleuchtung
SW39: X; TSE15_stehend_ohne_Beleuchtung
SW40: C; TSE15_stehend_ohne_Beleuchtung
SW41: V; TSE15_stehend_ohne_Beleuchtung
SW42: B; TSE15_stehend_ohne_Beleuchtung
SW43: N; TSE15_stehend_ohne_Beleuchtung
SW44: M; TSE15_stehend_ohne_Beleuchtung
SW45: <; TSE15_stehend_ohne_Beleuchtung
SW46: >; TSE15_stehend_ohne_Beleuchtung
SW47: /; TSE15_stehend_ohne_Beleuchtung
SW48: Enter; TSE15_stehend_ohne_Beleuchtung
U1: MH74154; DIP-24_W15.24mm_Socket
X11: Tastatur; Molex_SL_171971-0010_1x10_P2.54mm_Vertical

Connections:
+5P: C12.1, U1.24 (VCC), X11.10
/A0: U1.23 (A0), X11.5
/A1: U1.22 (A1), X11.6
/A2: U1.21 (A2), X11.7
/A3: U1.20 (A3), X11.8
/S0: SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, SW9.2, SW10.2, SW11.2, SW12.2, X11.4
/S1: SW13.2, SW14.2, SW15.2, SW16.2, SW17.2, SW18.2, SW19.2, SW20.2, SW21.2, SW22.2, SW23.2, SW24.2, X11.3
/S2: SW25.2, SW26.2, SW27.2, SW28.2, SW29.2, SW30.2, SW31.2, SW32.2, SW33.2, SW34.2, SW35.2, SW36.2, X11.2
/S3: SW37.2, SW38.2, SW39.2, SW40.2, SW41.2, SW42.2, SW43.2, SW44.2, SW45.2, SW46.2, SW47.2, SW48.2, X11.1
GND: C12.2, U1.12 (GND), U1.18 (E0), U1.19 (E1), X11.9
unnamed: SW1.1, SW13.1, SW25.1, SW37.1, U1.2 (S1)
unnamed: SW10.1, SW22.1, SW34.1, SW46.1, U1.11 (S10)
unnamed: SW11.1, SW23.1, SW35.1, SW47.1, U1.13 (S11)
unnamed: SW12.1, SW24.1, SW36.1, SW48.1, U1.14 (S12)
unnamed: SW2.1, SW14.1, SW26.1, SW38.1, U1.3 (S2)
unnamed: SW3.1, SW15.1, SW27.1, SW39.1, U1.4 (S3)
unnamed: SW4.1, SW16.1, SW28.1, SW40.1, U1.5 (S4)
unnamed: SW5.1, SW17.1, SW29.1, SW41.1, U1.6 (S5)
unnamed: SW6.1, SW18.1, SW30.1, SW42.1, U1.7 (S6)
unnamed: SW7.1, SW19.1, SW31.1, SW43.1, U1.8 (S7)
unnamed: SW8.1, SW20.1, SW32.1, SW44.1, U1.9 (S8)
unnamed: SW9.1, SW21.1, SW33.1, SW45.1, U1.10 (S9)

Notes on the sheet:
Quelle: jutecomp1.pdf S. 19
Quelle: JU+TE 11/1987, Seite 860-862
